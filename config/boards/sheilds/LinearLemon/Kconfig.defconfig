## config/boards/sheilds/LinearLemon/Kconfig.defconfig
```kconfig
if SHIELD_LINEARLEMON
           
config ZMK_KEYBOARD_NAME
    default "LinearLemon"

endif
```
